<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\legato_qs_9x60_ek_tm5000.IAR.ewp</path>
    </project>
    <batchBuild>
        </batchBuild>
    <project>
        <path>$WS_DIR$/legato_qs_9x60_ek_tm5000.IAR.ewp</path>
    </project>
</workspace>
